Commit message: Corrected rotor forces

File: simple_dragon.urdf (robot description, URDF)
Before this commit: robot L1, 12 links, 11 joints
Links:
- link G1: geometry 
- link G2: geometry 
- link L1: geometry collision box size=0.3 0.05 0.05
- link L2: geometry collision box size=0.3 0.05 0.05
